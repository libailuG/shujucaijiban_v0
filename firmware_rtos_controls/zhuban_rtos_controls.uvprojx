# Keil uVision project zhuban_rtos_controls.uvprojx, settings and files
target Zhuban_RTOS_Controls (6240000::V6.24::ARMCLANG)
  device: STM32H723ZGTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.3
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M7") CLOCK(550000000) FPU3 Dsp ELITTLE
  output: zhuban_rtos_controls +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32H723xx,ZHUBAN_RTOS_PHASE1,ZHUBAN_RTOS_CONTROLS
  c misc: -mfpu=fpv5-d16 -mfloat-abi=softfp -ffp-contract=off
  c include: .\App;.\Drivers\CMSIS\Device;.\Drivers\CMSIS\Core;.\ThirdParty\FreeRTOS-Kernel\include;.\ThirdParty\FreeRTOS-Kernel\portable\GCC\ARM_CM7\r0p1
  asm define: STM32H723xx,ZHUBAN_RTOS_PHASE1,ZHUBAN_RTOS_CONTROLS
  asm include: as above
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\board.sct
  link misc: --fpu=FPv5_D16
  group Core
    ./App/: main.c
  group RTOS
    ./App/: rtos_phase1.c rtos_phase1.h FreeRTOSConfig.h
    ./ThirdParty/FreeRTOS-Kernel/: tasks.c list.c
    ./ThirdParty/FreeRTOS-Kernel/portable/GCC/ARM_CM7/r0p1/: port.c portmacro.h
    ./ThirdParty/FreeRTOS-Kernel/include/: FreeRTOS.h task.h
  group Startup
    ./Startup/: system_stm32h7xx.c startup_stm32h723xx.s
  group Sensors
    ./App/: imu.c imu_bus.c icm_imu_i2c.c mahony.c battery.c imu.h imu_bus.h icm_imu_i2c.h mahony.h battery.h
  group Cascade
    ./App/: cascade_protocol.c cascade_receiver.c cascade_left.c cascade_right.c cascade_protocol.h cascade_receiver.h cascade_left.h cascade_right.h cascade_link.h cascade_port.inc
  group UART
    ./App/: reserved_uart2.c reserved_uart2.h reserved_uart1.c reserved_uart1.h mcu_uart_protocol.h mcu_uart_stream.h
  group Motor
    ./App/: motor_bus.c motor_bus.h motor_protocol.h
  group Mode_Normal
    ./App/: normal_mode.c normal_mode.h
  group Mode_Motor_Debug
    ./App/: motor_debug_mode.c motor_debug_mode.h
  group Mode_IMU_Debug
    ./App/: imu_debug_mode.c imu_debug_mode.h
  group Mode_Acquisition
    ./App/: acquisition_mode.c acquisition_mode.h
  group Mode_Control1
    ./App/: control_mode1.c control_mode1.h control_mode1_monitor.h control_mode1_observation.h
    ./App/control1_policy/: s2_deploy.c s2_deploy.h
  group Mode_Control2
    ./App/: control_mode2.c control_mode2.h control_mode2_telemetry.h
    ./App/control2_policy/: hip_assist_caiji_v0_policy.c hip_assist_caiji_v0_policy.h assist_oscillation_monitor.c assist_oscillation_monitor.h
  group Mode_Control3
    ./App/: control_mode3.c control_mode3.h
