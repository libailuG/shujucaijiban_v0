# Keil uVision project zhuban_recovery64.uvprojx, settings and files
target Zhuban_Recovery64 (6240000::V6.24::ARMCLANG)
  device: STM32H723ZGTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.3
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M7") CLOCK(64000000) FPU3 Dsp ELITTLE
  output: zhuban_recovery64 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32H723xx,BOARD_USE_550MHZ=0
  c include: .\App;.\Drivers\CMSIS\Device;.\Drivers\CMSIS\Core
  asm define: STM32H723xx,BOARD_USE_550MHZ=0
  asm include: .\App;.\Drivers\CMSIS\Device;.\Drivers\CMSIS\Core
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Sources
    ./App/: main.c
    ./Startup/: system_stm32h7xx.c startup_stm32h723xx.s
