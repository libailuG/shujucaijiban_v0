#include "stm32h7xx.h"
#include "imu.h"
#include "battery.h"
#include "reserved_uart2.h"

/* Schematic page 2: LED6 green=PG9, LED5 red=PG11, LED4 blue=PG14.
 * Anodes connect to 3.3 V through resistors: LOW=ON, HIGH=OFF. */
#define GREEN_LED (1UL << 9)
#define RED_LED   (1UL << 11)
#define BLUE_LED  (1UL << 14)
/* bit0=SW1/PC12, bit1=SW2/PC11, bit2=SW3/PB4; 1 means pressed.
 * State is published only after 20 consecutive equal 1ms samples. */
volatile uint32_t g_button_state;
static uint8_t button_debounce_ms[3];
static uint8_t green_on = 1U;
extern uint32_t BoardClock_Config550MHz(void);

static void buttons_init(void)
{
    RCC->AHB4ENR |= RCC_AHB4ENR_GPIOBEN | RCC_AHB4ENR_GPIOCEN;
    (void)RCC->AHB4ENR;
    /* Active-low switches; external pull-ups exist on the schematic.
     * Also enable internal pull-ups. PB4 is NJTRST after reset; selecting
     * GPIO input releases that function, while PA13/PA14 SWD stays intact. */
    GPIOC->MODER &= ~((3UL << 22) | (3UL << 24));
    GPIOC->PUPDR = (GPIOC->PUPDR & ~((3UL << 22) | (3UL << 24))) |
        (1UL << 22) | (1UL << 24);
    GPIOB->MODER &= ~(3UL << 8);
    GPIOB->PUPDR = (GPIOB->PUPDR & ~(3UL << 8)) | (1UL << 8);
}

static void buttons_scan_1ms(void)
{
    uint32_t pc = GPIOC->IDR;
    uint32_t pb = GPIOB->IDR;
    uint32_t raw = (((pc >> 12) & 1U) ^ 1U) |
        ((((pc >> 11) & 1U) ^ 1U) << 1) |
        ((((pb >> 4) & 1U) ^ 1U) << 2);
    for (uint32_t i = 0U; i < 3U; ++i) {
        uint32_t mask = 1UL << i;
        if (((raw ^ g_button_state) & mask) == 0U) {
            button_debounce_ms[i] = 0U;
        } else if (++button_debounce_ms[i] >= 20U) {
            button_debounce_ms[i] = 0U;
            g_button_state ^= mask;
        }
    }
}

void SysTick_Handler(void)
{
    buttons_scan_1ms();
}

static void led_timer_init(void)
{
    /* Fixed board clocks: HCLK=275MHz, APB1=137.5MHz, TIMPRE=0.
     * APB1 divider /2 doubles the timer kernel clock to 275MHz.
     * 275MHz / (27499+1) = 10kHz; ARR controls battery indication. */
    RCC->CFGR &= ~RCC_CFGR_TIMPRE;
    RCC->APB1LENR |= RCC_APB1LENR_TIM6EN;
    (void)RCC->APB1LENR;
    TIM6->CR1 = TIM_CR1_ARPE;
    TIM6->CR2 = 0U;
    TIM6->DIER = 0U;
    TIM6->PSC = 27499U;
    TIM6->ARR = 4999U;
    TIM6->CNT = 0U;
    TIM6->EGR = TIM_EGR_UG; /* Load PSC/ARR before starting the counter. */
    TIM6->SR = 0U; /* Discard the update event generated by UG. */
    NVIC_ClearPendingIRQ(TIM6_DAC_IRQn);
    NVIC_SetPriority(TIM6_DAC_IRQn, 3U);
    NVIC_EnableIRQ(TIM6_DAC_IRQn);
    TIM6->DIER = TIM_DIER_UIE;
    TIM6->CR1 |= TIM_CR1_CEN;
}

void TIM6_DAC_IRQHandler(void)
{
    if ((TIM6->SR & TIM_SR_UIF) != 0U) {
        TIM6->SR = 0U;
        green_on ^= 1U;
        GPIOG->BSRR = green_on ? (GREEN_LED << 16) : GREEN_LED;
    }
    __DSB(); /* Complete peripheral writes before exception return on M7. */
}

int main(void)
{
    const uint32_t leds = GREEN_LED | RED_LED | BLUE_LED;
    RCC->AHB4ENR |= RCC_AHB4ENR_GPIOGEN;
    (void)RCC->AHB4ENR;

    GPIOG->BSRR = leds; /* Set output latches OFF before enabling outputs. */
    GPIOG->OTYPER &= ~leds;
    GPIOG->PUPDR &= ~((3UL << 18) | (3UL << 22) | (3UL << 28));
    GPIOG->OSPEEDR &= ~((3UL << 18) | (3UL << 22) | (3UL << 28));
    GPIOG->MODER = (GPIOG->MODER &
        ~((3UL << 18) | (3UL << 22) | (3UL << 28))) |
        (1UL << 18) | (1UL << 22) | (1UL << 28);
    buttons_init();
    GPIOG->BSRR = GREEN_LED << 16; /* Start heartbeat immediately at boot. */

    if (BoardClock_Config550MHz() != 0U) {
        GPIOG->BSRR = RED_LED << 16;
        for (;;) { __NOP(); } /* Clock startup failed: keep red LED on. */
    }
    if (SysTick_Config(SystemCoreClock / 1000UL) != 0U) {
        for (;;) { /* Invalid tick configuration. */ }
    }
    led_timer_init();
    imu_init();
    battery_init();
    reserved_uart2_init();

    for (;;) {
        imu_poll();
        battery_poll();
        reserved_uart2_poll();
        /* ARPE applies the new half-period at the next timer update. */
        TIM6->ARR = g_battery_data.led_half_period_ms * 10U - 1U;
    }
}
